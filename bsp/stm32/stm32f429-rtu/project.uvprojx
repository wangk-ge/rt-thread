# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F429xx
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;board\ports\tb22;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\drv_flash;packages\at_device-latest\inc;packages\EasyFlash-latest\inc;packages\fal-latest\inc;packages\jsmn-latest\inc;packages\jsmn-latest\test;packages\kawaii-mqtt-latest\common;packages\kawaii-mqtt-latest\mqtt;packages\kawaii-mqtt-latest\mqttclient;packages\kawaii-mqtt-latest\network;packages\kawaii-mqtt-latest\platform\RT-Thread;packages\libmodbus-latest\examples;packages\libmodbus-latest\inc;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\termios;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\components\utilities\ulog;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c at_tb22.c at_cmd_rtu.c at_cmd_uart.c at_cmd_ulog.c at_cmd_misc.c util.c strref.c config.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: spi_flash_init.c ef_fal_port.c
    board/ports/tb22/: at_device_tb22.c at_socket_tb22.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_rtc.c drv_common.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group at_device
    packages/at_device-latest/src/: at_device.c
  group EasyFlash
    packages/EasyFlash-latest/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
  group jsmn
    packages/jsmn-latest/src/: jsmn.c
  group kawaii_mqtt
    packages/kawaii-mqtt-latest/common/: list.c random.c
    packages/kawaii-mqtt-latest/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
    packages/kawaii-mqtt-latest/network/: network.c
    packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_memory.c platform_mutex.c platform_net_socket.c platform_nettype_tcp.c platform_nettype_tls.c platform_thread.c platform_timer.c
  group libmodbus
    packages/libmodbus-latest/src/: modbus.c modbus-data.c modbus-rtu.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
    ../../../components/libc/termios/: posix_termios.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_server.c at_base_cmd.c at_client.c
    ../../../components/net/at/at_socket/: at_socket.c
  group netdev
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/socket/: net_netdb.c
    ../../../components/net/sal_socket/impl/: af_inet_at.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
  group STM32_HAL
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
